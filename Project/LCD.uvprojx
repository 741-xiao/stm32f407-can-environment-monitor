# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --no_multibyte_chars
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4xx_HAL_Driver\inc;..\USER\LED;..\USER\LCD;..\USER\BEEP;..\USER\KEY;..\USER\SHT30;..\USER\Chinese;..\USER\Serial;..\USER\WiFi;..\USER\Light;..\USER\Air;..\USER\OLED;..\USER\CAN;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main_sensor.c app_rtos.c FreeRTOSConfig.h dual_logic.c app_logic.c stm32f4xx_it.c
  group FreeRTOS
    ../Middlewares/FreeRTOS/: tasks.c queue.c list.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Startup_config
    ../Startup_config/: system_stm32f4xx.c stm32f4xx_hal_msp.c startup_stm32f407xx.s cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h
  group USER
    ../USER/LED/: led.c led_effect.c
    ../USER/BEEP/: beep.c
    ../USER/KEY/: key.c
    ../USER/LCD/: lcd.c
    ../USER/SHT30/: sht30.c
    ../USER/Chinese/: chinese_lcd.c
    ../USER/Serial/: serial.c
    ../USER/Light/: light.c
    ../USER/WiFi/: wifi_link.c
    ../USER/Air/: air_sensor.c
    ../USER/OLED/: ssd1306.c
    ../USER/CAN/: can_link.c
    ../Main/: tri_can_logic.c
  group STM32F4_HAL_FWLIB
    ../STM32F4xx_HAL_Driver/src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_iwdg.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_can.c
  group Common
    ../Common/: common.c
software components: CMSIS:CORE 4.3.0
